# Keil uVision project EEPROM - hien.uvprojx, settings and files
target Core (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: simon_says +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./: main.c delay.c gpio_driver.c i2c_driver.c lcd_i2c.c dem.c eeprom_i2c.c lm75.c Sensor_mon.c log_eeprom.c
  group Inc
    ./: lcd_i2c.h delay.h gpio_driver.h i2c_driver.h dem.h eeprom_i2c.h lm75.h Sensor_mon.h log_eeprom.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
